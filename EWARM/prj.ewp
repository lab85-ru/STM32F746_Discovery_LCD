# IAR project prj.ewp, settings and files
configuration prj (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx
  ICCARM.CCIncludePath2: ../src/CMSIS/Include; ../src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: prj.hex
  ILINK.IlinkOutputFile: prj.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../src/: ltdc.c ltdc.h
  group src
    ../src/: clk_746.c clk_746.h image.h main.c main.h startup_stm32f746xx.s stm32f746xx.h stm32f7xx_it.c stm32f7xx_it.h system_stm32f7xx.c system_stm32f7xx.h
